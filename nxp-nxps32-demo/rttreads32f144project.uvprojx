# Keil uVision project rttreads32f144project.uvprojx, settings and files
target rttread-s32f144 (ARM-ADS)
  device: S32K144UAxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rttreads32f144project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_S32K144HFT0VLLT,CORE_M4
  c include: .\Application\Inc;.\Drivers\Inc;.\S32Drivers\Inc;.\CMSIS;.\S32Drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\CMSIS\S32K144_64_ram.sct
  group Appilcation
    ./Application/Src/: main.c
  group Drivers
    ./Drivers/Src/: clockMan1.c Cpu.c pin_mux.c
  group S32Drivers
    ./S32Drivers/Src/clock/S32K1xx/: clock_S32K1xx.c
    ./S32Drivers/Src/interrupt/: interrupt_manager.c
    ./S32Drivers/Src/pins/: pins_driver.c pins_port_hw_access.c
  group CMSIS
    ./CMSIS/: startup_S32K144.s system_S32K144.c startup.c
